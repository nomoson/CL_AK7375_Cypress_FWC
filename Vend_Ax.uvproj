# Keil uVision project Vend_Ax.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: AK7375 +hex
  AfterMake: C:\Cypress\USB\bin\Hex2bix -I -f 0xc2 -o AK7375.iic AK7375.hex
  c flags: Optimize=6 SizeSpeed=1
  c define: NO_RENUM
  group Source Group 1
    ./: FW.C VEND_AX.C DSCR.A51 EZUSB.LIB USBJmpTb.OBJ
